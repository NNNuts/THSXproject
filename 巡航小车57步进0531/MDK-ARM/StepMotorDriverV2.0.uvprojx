# Keil uVision project StepMotorDriverV2.0.uvprojx, settings and files
target StepMotorDriverV2.0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: StepMotorDriverV2.0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;   ../Drivers/STM32F1xx_HAL_Driver/Inc;   ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;   ../Drivers/CMSIS/Include;   ../MDK-ARM/Oledlib;   ../MDK-ARM/TMClib;   ../MDK-ARM/Buttonlib
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_can.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Oledlib
    ./Oledlib/: draw_api.h oled_basic.c oled_basic.h oled_bmp.c oled_bmp.h oled_buffer.c oled_buffer.h oled_color.c oled_color.h oled_config.c oled_config.h oled_debug.c oled_debug.h oled_draw.c oled_draw.h oled_driver.c oled_driver.h oled_font.c oled_font.h test.c test.h
  group TMClib
    ./TMClib/: SPI_TMC.c SPI_TMC.h TMC5160.c TMC5160.h TMC5160_Mask_Shift.h TMC5160_Register.h
  group Buttonlib
    ./Buttonlib/: multi_button.c multi_button.h
software components: CMSIS:CORE 5.4.0
